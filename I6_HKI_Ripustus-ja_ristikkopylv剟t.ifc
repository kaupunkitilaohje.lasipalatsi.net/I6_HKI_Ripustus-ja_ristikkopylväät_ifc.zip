Properties of the parts of a building model (IFC2X3)

# File
Description: IFC 2x3 Building Model
Time: 2021-02-09T15:43:25
Author: Mayow, Feodor
Organization: WSP Europe
Made in: ASIFC - 2.11.0.854

# IfcSite
RefElevation: 0 mm

# IfcProxy (12)
ProxyType: PRODUCT
Name
2 x L6
2 x L6.005
2 x L6.004
2 x L6.003
2 x L6.002
2 x L6.001
